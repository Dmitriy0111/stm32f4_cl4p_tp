# Keil uVision project stm32f407_test_proj.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407_test_proj
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\spl\inc;.\prog;.\Device\inc;.\cmsis\inc;.\sdcard;.\spi_drv
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group spl_inc
    ./spl/inc/: misc.h stm32f4xx_exti.h stm32f4xx_gpio.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h
  group spl_src
    ./spl/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group dev_inc
    ./Device/inc/: stm32f4xx.h system_stm32f4xx.h
  group dev_src
    ./Device/src/: system_stm32f4xx.c startup_stm32f40xx.s
  group prog
    ./prog/: main.c main.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group cmsis
    ./cmsis/inc/: core_cm4.h
  group sdcard
    ./sdcard/: sdcard.h sdcard.c
  group spi_drv
    ./spi_drv/: spi_drv.c spi_drv.h
